# Keil uVision project FreeRTOSprj.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: FreeRTOSprj
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\OS_src\include;..\STM32F10xFWLib\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group USER_Source
    ./: main.c stm32f10x_it.c
  group FreeRTOS_src
    ../OS_src/core_src/: croutine.c event_groups.c list.c queue.c readme.txt tasks.c timers.c
  group FreeRTOS_port_m3
    ../OS_src/port_m3/: heap_4.c port.c
  group FreeRTOS_config
    ../OS_src/include/: FreeRTOSConfig.h
  group Doc
    ./: README.txt
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.1
